# Keil uVision project Lab1.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1968 Texas Instruments
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Lab1
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Startup.s Output.h rit128x96x4.h fixed.h fixed.c Lab1.c
